# Keil uVision project aufgabe_4.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RB2 Microchip
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0 - 0xFF) CLOCK(60000000) MODP2
  output: aufgabe_4
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: aufgabe_4.a51
